# Keil uVision project STM32_uCOS_BSP_LIB.uvproj, settings and files
target STM32_uCOS_BSP_LIB (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_uCOS_BSP_LIB +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,JKB_SW_H
  c misc: --c99
  c include: ..\FWlib\inc;..\CMSIS;..\App;..\Bsp;..\uCOS-II\Source;..\uCOS-II\Config;..\uCOS-II\Ports;..\Bsp\usb;..\STM32_USB-FS-Device_Driver\inc;..\STM32_USB-FS-Device_Driver\src;..\SEGGER\RTT
  memory RVCT4: ROM 0x8010000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../App/: main.c stm32f10x_it.c ADC_Sample_Task.c Keyboard_Task.c Display_Task.c RC_Bus_Task.c HID_Task.c
  group Bsp
    ../Bsp/: led.c adc.c usbHID.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c hw_config.c flash_in_stm32.c Stm32Usart.c
  group FWLib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group StartUp
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group uCOS-II\Soure
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II\Ports
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group STM32_USB-FS-Device_Driver
    ../STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Debug
    ../SEGGER/Syscalls/: RTT_Syscalls_KEIL.c
    ../SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
target BasePro (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: as above
  output: STM32_uCOS_BSP_LIB +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8010000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x5000
